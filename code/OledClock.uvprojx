# Keil uVision project OledClock.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OledClock
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\StdPeriphLIB\inc;.\StdPeriphLIB\src;.\USER;.\STARTCODE;C:\Keil_v5\ARM\PACK\Keil\STM32F1xx_DFP\2.3.0\Device\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.8.0\CMSIS\Core\Include;.\BSP;.\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c system_stm32f10x.c self_stm32f10x.c
  group FWLIB
    ./StdPeriphLIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STARTCODE
    ./STARTCODE/: startup_stm32f10x_md.s
  group BSP
    ./BSP/: bsp_spi.c bsp_led.c bsp_usart.c bsp_hard_delay.c bsp_key.c
  group HARDWARE
    ./HARDWARE/: oled12864.c ds18b20.c w25q16.c
software components: CMSIS:CORE 5.5.0
